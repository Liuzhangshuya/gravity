# Keil uVision project CtrBoard.uvprojx, settings and files
target CtrBoard (6230000::V6.23::ARMCLANG)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CtrBoard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F446xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/bsp;../User/driver;../User/motor;../User/module;..\User\1-APL(Application Layer)\inc;..\User\2-MWL(Middleware Layer)\inc;../User/gravity;../lib/Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group bsp
    ../User/bsp/: can_bsp.c adc_bsp.c key_bsp.c led_bsp.c
  group driver
    ../User/driver/: can_driver.c adc_driver.c key_driver.c led_driver.c
  group motor
    ../User/motor/: dm4310_ctrl.c dm4310_drv.c
  group modlue
    ../User/module/: adc_modlue.c key_modlue.c mcu_config.c scheduler.c task.c display.c lcd.c
  group 1-APL(Application Layer)
    ../User/1-APL(Application Layer)/inc/: remote_control.h fsm.h
    ../User/1-APL(Application Layer)/src/: remote_control.c fsm.c
  group 2-MWL(Middleware Layer)
    ../User/2-MWL(Middleware Layer)/inc/: CRC8_CRC16.h motor_protect.h button_status_read.h motor_function.h
    ../User/2-MWL(Middleware Layer)/src/: CRC8_CRC16.c motor_protect.c button_status_read.c motor_function.c
  group gravity
    ../User/gravity/: robot_parameters.h gravity_config.h gravity.c gravity_comp.c gravity_math.c cartesian_assist.c cartesian_assist.h
  group arm_math
    ../lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.6.0
